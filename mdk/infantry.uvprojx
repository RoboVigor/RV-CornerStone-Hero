# Keil uVision project infantry.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Belief exp2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=5 wLevel=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,ROBOT_LOOP_ONE.__TARGET_FPU_CM4,ARM_MATH_CM4,__CC_ARM,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --gnu
  c include: ..\core;..\bsp\inc;..\driver\inc;..\library\std\inc;..\user;..\library\freertos\include;..\library\freertos\portable\RVDS\ARM_CM4F;..\user\common;..\library\atom\delay;..\library\atom\sys;..\library\atom\usart;..\library\atom\debug;..\library\mpu6500;..\user\infantry;..\library\vegmath;..\user\common;..\device\inc;..\library\ekf;..\library\usb\STM32_USB_OTG_Driver\inc;..\library\usb\STM32_USB_Device_Library\Core\inc;..\library\usb\STM32_USB_Device_Library\Class\cdc\inc;..\library\DM_Driver
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ../core/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f427xx.s
  group library
    ../library/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../library/freertos/portable/MemMang/: heap_4.c
    ../library/freertos/portable/RVDS/ARM_CM4F/: port.c
    ../library/atom/delay/: delay.c
    ../library/atom/sys/: sys.c
    ../library/mpu6500/: MadgwickAHRS.c mpu6500_driver.c mpu6500_i2c.c
    ../library/atom/debug/: beep.c key.c led.c
    ../library/vegmath/: vegmath.c
    ../library/atom/usart/: usart.c
    ../library/ekf/: gyro_bias_estimator.c orientation_ekf.c low_pass_filter.c matrix3x3d.c so3_helper.c vector3d.c
    ../library/usb/STM32_USB_OTG_Driver/src/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c
    ../library/usb/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
    ../library/usb/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c usbd_cdc_if.c
    ../library/DM_Driver/: DM_Driver.c
  group driver
    ../driver/src/: Driver_CAN.c Driver_PID.c Driver_Magic.c Driver_Chassis.c Driver_Motor.c Driver_Filter.c Driver_Gyroscope.c Driver_BSP.c Driver_Protocol.c Driver_Fsm.c Driver_Bridge.c Driver_Vofa.c Driver_Remote.c
  group user_common
    ../user/common/: macro.h system_stm32f4xx.c interrupt.h
  group user_loop_infantry
    ../user/infantry/: interrupt.c main.c tasks.c cmd.c params.c
  group device
    ../device/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c
